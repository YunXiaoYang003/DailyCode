# Keil uVision project 实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 18b20.c 18b20.h main.c delay.h delay.c 1602.c
    ../../2022.10.27_上课实验/keil/: 1602.h
